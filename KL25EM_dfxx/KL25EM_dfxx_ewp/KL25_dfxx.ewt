<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\src\app\DataCollection.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DataCollection.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DataProcessing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DataProcessing.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DebugEM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DebugEM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DriverMS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\DriverMS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\InitEM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\InitEM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\isr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\mian.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\OutputControl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\OutputControl.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\setup.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\SimulatTimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\SimulatTimer.h</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\src\common\alloc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\assert.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\io.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\memtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\memtest.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\queue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\startup.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\stdlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\stdlib.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\typedef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\uif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\uif.h</name>
    </file>
  </group>
  <group>
    <name>cpu</name>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\arm_cm0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\dma_channels.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\headers\MKL25Z4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\sysinit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\vectors.h</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\adc\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\cmp\cmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\dac\dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\DMA\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\gpio\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\i2c\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\lptmr\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\mcg\mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\pit\pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\port\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\rtc\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\spi\SPI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\tpm\tpm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\tsi\tsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\uart\uart.c</name>
    </file>
  </group>
  <group>
    <name>headers</name>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\fire_drivers_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\gpio\gpio_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\drivers\i2c\i2c_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\app\include.h</name>
    </file>
  </group>
  <group>
    <name>other</name>
    <file>
      <name>$PROJ_DIR$\..\src\other\LandzoOLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\other\LandzoOLED.h</name>
    </file>
  </group>
  <group>
    <name>platforms</name>
    <file>
      <name>$PROJ_DIR$\..\src\platforms\freedom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\platforms\tower.h</name>
    </file>
  </group>
</project>


