# IAR project KL25_dfxx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; IAR; MKL25Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\src\app; ..\src\common; ..\src\common\io; ..\src\common\startup; ..\src\cpu; ..\src\cpu\headers; ..\src\landzo; ..\src\cpu\headers; ..\src\drivers; ..\src\drivers\gpio; ..\src\drivers\i2c; ..\src\drivers\lptmr; ..\src\drivers\mcg; ..\src\drivers\uart; ..\src\drivers\port; ..\src\drivers\dma; ..\src\drivers\pit; ..\src\drivers\tpm; ..\src\drivers\ADC; ..\src\platforms; ..\src\other; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KL25_dfxx.srec
  ILINK.IlinkOutputFile: KL25_dfxx.out
  ILINK.IlinkIcfFile: F:\KL25EM\KL25EM_dfxx\ConfigFiles\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/app/: DataCollection.c DataCollection.h DataProcessing.c DataProcessing.h DebugEM.c DebugEM.h DriverMS.c DriverMS.h InitEM.c InitEM.h isr.c isr.h mian.c OutputControl.c OutputControl.h setup.h SimulatTimer.c SimulatTimer.h
  group common
    ../src/common/: alloc.c assert.c assert.h common.c common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group cpu
    ../src/cpu/: arm_cm0.c arm_cm0.h crt0.s dma_channels.h start.c sysinit.c sysinit.h vectors.c vectors.h
    ../src/cpu/headers/: MKL25Z4.h
  group drivers
    ../src/drivers/adc/: adc.c
    ../src/drivers/cmp/: cmp.c
    ../src/drivers/dac/: dac.c
    ../src/drivers/DMA/: dma.c
    ../src/drivers/gpio/: gpio.c
    ../src/drivers/i2c/: i2c.c
    ../src/drivers/lptmr/: lptmr.c
    ../src/drivers/mcg/: mcg.c
    ../src/drivers/pit/: pit.c
    ../src/drivers/port/: port.c
    ../src/drivers/rtc/: rtc.c
    ../src/drivers/spi/: SPI.c
    ../src/drivers/tpm/: tpm.c
    ../src/drivers/tsi/: tsi.c
    ../src/drivers/uart/: uart.c
  group headers
    ../src/drivers/: fire_drivers_cfg.h
    ../src/drivers/gpio/: gpio_cfg.h
    ../src/drivers/i2c/: i2c_cfg.h
    ../src/app/: include.h
  group other
    ../src/other/: LandzoOLED.c LandzoOLED.h
  group platforms
    ../src/platforms/: freedom.h tower.h
