<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KL25EM_dfxx\KL25EM_dfxx_ewp\KL25_dfxx.ewp</path>
  </project>
  <batchBuild/>
</workspace>


